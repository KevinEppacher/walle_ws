Commit message: Gathered Data

File: src/amr_control/urdf/cube.urdf (robot description, URDF)
Before this commit: robot cube_robot, 1 links, 0 joints
Links:
- link cube_link: geometry collision box size=0.2 0.2 0.2; visual box size=0.2 0.2 0.2
